# Keil uVision project Ekit.uvprojx, settings and files
target Ekit (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Ekit +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ..\CORE;..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HALLIB\STM32F1xx_HAL_Driver\Inc;..\HARDWARE\LED;..\HARDWARE\LCD;..\HARDWARE\KEY;..\HARDWARE\24CXX;..\HARDWARE\IIC;..\HARDWARE\SPI;..\HARDWARE\TOUCH;..\HARDWARE\W25QXX;..\HARDWARE\WAVE_OUTPUT;..\EMWIN\STemWin\Config;..\EMWIN\STemWin\inc;..\HARDWARE\SRAM;..\HARDWARE\MALLOC;..\GUIBulder;..\HARDWARE\TIMER;..\HARDWARE\ADC;..\HARDWARE\DAC;..\HARDWARE\DMA;..\SYSTEM\STM32_FFT;..\HARDWARE\NRF24L01;..\HARDWARE\SYN6288;..\HARDWARE\AD9850
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f1xx_hal_msp.c stm32f1xx_it.c system_stm32f1xx.c
  group CORE
    ../CORE/: cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h core_cm3.h startup_stm32f103xe.s
  group HALLIB
    ../HALLIB/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_sram.c stm32f1xx_ll_fsmc.c stm32f1xx_hal_spi.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/STM32_FFT/: my_fft.c cr4_fft_256_stm32.s cr4_fft_1024_stm32.s
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/TOUCH/: ctiic.c ft5206.c gt9147.c ott2001a.c touch.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/SRAM/: sram.c
    ../HARDWARE/MALLOC/: malloc.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/DAC/: dac.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/DMA/: dma.c
    ../HARDWARE/NRF24L01/: 24l01.c
    ../HARDWARE/SYN6288/: SYN6288.c
    ../HARDWARE/AD9850/: AD9850.c
    ../HARDWARE/WAVE_OUTPUT/: wave_output.c
  group README
    ../: readme.txt
  group EMWIN_LIB
    ../EMWIN/STemWin/Lib/: STemWin526_CM3_Keil.lib
  group EMWIN_Config
    ../EMWIN/STemWin/Config/: GUI_X_Touch_Analog.c GUIConf.c GUIDRV_Template.c LCDConf_FlexColor_Template.c
    ../EMWIN/STemWin/OS/: GUI_X.c
  group GUIBulder
    ../GUIBulder/: AFCFramewinDLG.c LogWindowDLG.c mainFramewinDLG.c oscilloscopeFramewinDLG.c SingalWindowDLG.c
