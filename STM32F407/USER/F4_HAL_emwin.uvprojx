# Keil uVision project F4_HAL_emwin.uvprojx, settings and files
target F4_HAL_emwin (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: F4_HAL_emwin +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\CORE;..\USER;..\OBJ;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HALLIB\STM32F4xx_HAL_Driver\Inc;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\TIMER;..\HARDWARE\SRAM;..\HARDWARE\TOUCH;..\HARDWARE\IIC;..\HARDWARE\SPI;..\HARDWARE\24CXX;..\HARDWARE\W25QXX;..\MALLOC;..\DSP_LIB\Include;..\EMWIN\STemWin\inc;..\EMWIN\STemWin\Config;..\GUIBulder;..\HARDWARE\WAVE_OUTPUT;..\HARDWARE\ADC;..\HARDWARE\DAC;..\HARDWARE\DMA;..\HARDWARE\TIM;..\HARDWARE\GPIO;..\SYSTEM\my_fft
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c stm32f4xx_hal_msp.c
  group CORE
    ../CORE/: core_cm4.h cmsis_armcc.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f407xx.s
  group HALLIB
    ../HALLIB/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/my_fft/: my_fft.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/LCD/: ILI93xx.c
    ../HARDWARE/SRAM/: sram.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/TOUCH/: touch.c ctiic.c ft5206.c gt9147.c ott2001a.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/WAVE_OUTPUT/: wave_output.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/DAC/: dac.c
    ../HARDWARE/DMA/: dma.c
    ../HARDWARE/TIM/: tim.c
    ../HARDWARE/GPIO/: gpio.c
  group DSP_LIB
    ../DSP_LIB/: arm_cortexM4lf_math.lib
    ../DSP_LIB/Include/: arm_math.h
  group EMWIN_Config
    ../EMWIN/STemWin/OS/: GUI_X.c
    ../EMWIN/STemWin/Config/: GUIConf.c GUIDRV_Template.c GUI_X_Touch_Analog.c LCDConf_FlexColor_Template.c
  group EMWIN_LIB
    ../EMWIN/STemWin/Lib/: STemWin526_CM4_Keil.lib
  group MALLOC
    ../MALLOC/: malloc.c
  group GUIBulder
    ../GUIBulder/: mainFramewinDLG.c LogWindowDLG.c SingalWindowDLG.c AFCFramewinDLG.c oscilloscopeFramewinDLG.c
